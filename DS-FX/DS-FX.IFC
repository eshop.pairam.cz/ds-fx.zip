Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DS-FX.IFC
Time: 2021-10-18T11:13:04
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DS-FX
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
